Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2019-06-20T13:29:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 20 13:29:29 2019 * Host: Piranha * Database: C:\Users\datBIM\AppData\Local\Temp\{0807A751-0A10-4DD1-80DB-C56EE360B924}\ifc * Database version: 5507 * Database creation date: Thu Jun 20 13:29:26 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 20 13:29:28 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 20 13:29:28 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 mm
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no

# IfcBuildingElementProxy: AESI 24V 3A C24 SB G, AESI 24V 3A C24 SB G:AESI 24V 3A C24 SB G:138053
In: Niveau 1
Type - Autre - Catégorie: Equipement électrique; datBIM.Classe electrique (Electrical class): 1; datBIM.Code datBIM entité: 2340324000; datBIM.Code produit SLAT (Id SlatEntityCode): 2340324000; datBIM.Conformite ATEX (ATEX compliance): Non (No); datBIM.Conformité normative AES : NF EN 12101-10 - EAE (Normative conformity SPS: NF EN 12101-10 - Energy supply equipment): Conforme (Compliant); datBIM.Conformité normative EAE : NF EN 54-4 + A1 + A2 (Normative conformity : NF EN 54-4 + A1 + A2 - Power supply equipment): Conforme (Compliant); datBIM.Consommation electrique (Primary current): 0,78; datBIM.Couleur dominante (Dominant color): Blanc RAL 9003 (White RAL 9003); datBIM.Courant maximal d'utilisation (Maximal output current): 3; datBIM.Degre d'etancheite IP (Protection class IP): IP30; datBIM.Description longue entité: <p> <img title="C 24 AES.jpg" src="https://admin.datbim.com/media/mid/1/22188.jpg" alt="" width="241" height="187" data-idmedia="22188" /></p><p><em>Ref. : 2340324000<br /></em></p><p>Les alimentations sécurisées AESI fournissent l?énergie permanente d?alimentation et de secours pour les installations de Sécurité Incendie / The AESI emergency power supplies provide permanent and backup power for Fire Safety installations.</p>; datBIM.Designation technique (Technical designation): AES, EAE, EAES; datBIM.Duree de la garantie (Length of warranty): 3 ans; datBIM.Duree de vie previsionnelle (Expected life expectancy): 10 ans; datBIM.Duree de vie previsionnelle de reconditionnement (Expected life of refurbishment): 4 ans; datBIM.Fonction generique (Generic function): Alimentation électrique (Power supply); datBIM.Hauteur (Height): 247.5 mm; datBIM.Hauteur hors tout (Height overall): 247.5 mm; datBIM.Id: datBIM:383279; datBIM.Largeur (Wide): 321 mm; datBIM.Largeur hors tout (Wide overall): 321 mm; datBIM.Libellé entité: AESI 24V 3A C24 SB G; datBIM.Longueur (Length): 121.5 mm; datBIM.Longueur hors tout (Length overall): 125.2 mm; datBIM.Marque commerciale (Commercial brand): SLAT; datBIM.Matiere de l'enveloppe (Envelope material): Acier - ABS (Steel - ABS plastic); datBIM.Mode de communication (Communication mode): Contact sec (Dry contact); datBIM.Nombre de sorties d'alimentation (Number of power supply outputs): 2; datBIM.Poids (Weight): 2.5; datBIM.Point de fixation (Mounting point): 3; datBIM.Produit repartis dans plusieurs enveloppes (Product divided into several envelopes): Non (No); datBIM.Puissance (Output power): 75 W; datBIM.Qualification d'installateur : NF S 61-932 - Règles d’installation (Installer qualification : NF S 61-932 - Installation rules): Recommande (Recommanded); datBIM.Qualification d'installateur : NF S 61-970 - Règles d'installation des systèmes de détection incendie (Installer qualification : Installation rules for fire detection systems): Recommande (Recommanded); datBIM.Qualification d'installateur : R7 (Installer qualification : R7): Recommande (Recommanded); datBIM.Qualification du mainteneur : Annexe B NF S 61-933 - SDI (Qualification of the maintainer : Appendix B NF S 61-933 - SDI): Recommande (Recommanded); datBIM.Qualification du mainteneur : Annexe J NF S 61-933 Alimentation (Qualification of the maintainer : Appendix J NF S 61-933 Power supply): Recommande (Recommanded); datBIM.Qualification du mainteneur : Annexe L NF S 61-933 Exploitant (Qualification of the maintainer : Appendix L NF S 61-933 Operator): Recommande (Recommanded); datBIM.Rendement energetique (Energy efficiency): 90,1; datBIM.Substance visee par REACH_DEEE (Substance covered by REACH_DEEE): Non (No); datBIM.Temperature d'utilisation (Operating temperature): -10 à +55 °C; datBIM.Tension de fonctionnement [Min-Max] (Mains voltage [Min-Max]): 115-240 V; datBIM.Tension nominale de sortie (Rated output voltage): 24 V; datBIM.Type de liaison (Type of link): Filaire (Wired); datBIM.Type d'installation (Mounting type): Mural (Wall-mounted); Nom de la famille: AESI 24V 3A C24 SB G
Type - Données d'identification - Fabricant: SLAT; Nom du type: AESI 24V 3A C24 SB G
Pset_BuildingElementProxyCommon - Reference: AESI 24V 3A C24 SB G
Pset_ManufacturerTypeInformation - Manufacturer: SLAT
Autre - Famille: AESI 24V 3A C24 SB G: AESI 24V 3A C24 SB G; Famille et type: AESI 24V 3A C24 SB G: AESI 24V 3A C24 SB G; ID du type: AESI 24V 3A C24 SB G: AESI 24V 3A C24 SB G; Type: AESI 24V 3A C24 SB G: AESI 24V 3A C24 SB G
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 0.137398 m2; Volume: 0.00769697 m3
Données d'identification - Identifiant: 1
Electricité - Charges - Charge apparente - Phase A: 0 W; Charge apparente - Phase B: 0 W; Charge apparente - Phase C: 0 W; Charge totale connectée: 0 W; Demande de charge totale estimée: 0 W; Facteur de charge totale: 1
Phase de construction - Phase de création: Phase 1
